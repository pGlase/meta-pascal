FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
CONFFILES_${PN} = "${sysconfdir}/network/interfaces"
